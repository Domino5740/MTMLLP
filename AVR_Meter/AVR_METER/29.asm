.MACRO LOAD_CONST
LDI @0, LOW(@2)
LDI @1, HIGH(@2)
.ENDMACRO

LDI R18, $FF 
LDI R19, $3F
LDI R20, $06
LDI R21, $02
OUT DDRD, R18
OUT DDRB, R18
OUT PORTB, R21

MainLoop:
OUT PORTD, R19
RCALL DelayInMs
OUT PORTD, R20
RCALL DelayInMs
RJMP MainLoop

DelayInMs:
	LOAD_CONST R16, R17, 250
	MOV R25, R17
	MOV R24, R16
	Ms:
		PUSH R25
		PUSH R24
		RCALL DelayOneMs
		POP R24
		POP R25
		SBIW R25:R24, 1
	BRNE Ms
RET

DelayOneMs:
	LOAD_CONST R24, R25, 2000
	OneMs:
		SBIW R25:R24, 1
	BRNE OneMs
RET